# Keil uVision project H743_Signal_Processor.uvprojx, settings and files
target H743_Signal_Processor (ARM-ADS)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H743_Signal_Processor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../../Algorithm/Inc;../../Algorithm/Private;../../Protocol/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\H743_Signal_Processor.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c processor_app.c spi_links.c
  group Application/SignalAlgorithm
    ../../Algorithm/Src/: signal_analyzer.c signal_preprocess.c signal_fft_portable.c spectrum_detect.c czt_zoom.c harmonic_model.c orthogonal_fit.c signal_metrics.c
  group Application/Protocol
    ../../Protocol/Src/: h743_crc32.c h743_result_protocol.c h743_set_fs_protocol.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
software components: CMSIS:CORE 4.3.0
